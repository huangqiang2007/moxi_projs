# Keil uVision project adc.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: face-eye-mask.hex +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./face-eye-mask.bin ./adc.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\user;..\stm32f0;..\drive;..\lib\inc;..\lib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group lib
    ../lib/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_spi.c stm32f0xx_i2c.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_pwr.c
  group user
    ./: main.c
  group drive
    ../drive/: adc.c systick.c uart.c 24cxx.c delay.c myiic.c key.c led.c time.c
    ../stm32f0/: stm32f0xx_it.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.4.0
