# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F030 MCU_LOW_POWER_MODE USE_STDPERIPH_DRIVER HSE_VALUE=16000000  ADC_USE_DMA ADC_DMA_IRQ  USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CORE
    ../CORE/: startup_stm32f030x6.s
  group FWLIB
    ../FWLIB/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group DRIVER
    ../drive/: led.c key.c systick.c time.c exit.c adc.c wdog.c uart.c
